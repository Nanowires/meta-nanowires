PACKAGECONFIG:append = " fastcgi "