# Tweaks needed for imagick to compile
SYSROOT_DIRS += "${bindir}"